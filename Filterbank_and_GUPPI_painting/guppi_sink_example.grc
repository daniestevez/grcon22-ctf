options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: guppi_sink_example
    output_language: python
    title: GUPPI File Sink example
  states: {}

blocks:
- name: num_channels
  id: variable
  parameters:
    value: '64'
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: taps_per_channel * num_channels
  states: {}
- name: polyphase_taps
  id: variable
  parameters:
    comment: Polyphase prototype filter designed using Remez
    value: scipy.signal.remez(num_taps, [0, 0.35/num_channels, 0.65/num_channels, 0.5], [1, 0])
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e6
  states: {}
- name: taps_per_channel
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: 128 * 32
    vector_output: 'False'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: '6'
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: '3'
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: '7'
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: '4'
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: '5'
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/grcon2022-ctf/painting.c64
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: polyphase_taps[0*num_channels:1*num_channels][::-1]
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: polyphase_taps[1*num_channels:2*num_channels][::-1]
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: polyphase_taps[2*num_channels:3*num_channels][::-1]
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: polyphase_taps[3*num_channels:4*num_channels][::-1]
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: polyphase_taps[4*num_channels:5*num_channels][::-1]
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: polyphase_taps[5*num_channels:6*num_channels][::-1]
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: polyphase_taps[6*num_channels:7*num_channels][::-1]
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: polyphase_taps[7*num_channels:8*num_channels][::-1]
    type: complex
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_channels
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: 2 * num_channels
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: num_channels
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_channels
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: guppi_guppi_sink_0
  id: guppi_guppi_sink
  parameters:
    az: 91+6/60+53.5/3600
    dec: 30 + 30/60 + 32.96/3600
    filename: ATA_59839_73822_3C286.0000.raw
    ndim: 2**20
    npol: '1'
    obsbw: samp_rate
    observer: Daniel Estevez
    obsfreq: 8.4e9 - 0.5*samp_rate/num_channels
    obsnchan: num_channels
    proj_id: GRCON2022 CTF
    ra: 13/24*360 + 31/(24*60)*360 + 8.28811/(24*3600)*360
    src_name: 3C286
    stt_mjd: 59839 + 17/24 + 43/(60*24) + 3/(3600*24)
    telescope: ATA
    za: 90-(39+30/60+53.7/3600)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import scipy.signal
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: Input signal generation
  states: {}
- name: note_1
  id: note
  parameters:
    note: Polyphase filterbank
  states: {}
- name: note_2
  id: note
  parameters:
    note: GUPPI file output
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: Input
    name: ''
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '100000'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: polyphase_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: polyphase_out
  states: {}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_1, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_delay_0_1_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_2, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [blocks_delay_0_3, '0', blocks_multiply_const_vxx_0_0_0_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_0_0_0_0_0, '0', blocks_add_xx_0, '5']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_0, '0', blocks_add_xx_0, '6']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_0_0, '0', blocks_add_xx_0, '7']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_delay_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_delay_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_delay_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_delay_0_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_delay_0_1_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_delay_0_2, '0']
- [blocks_stream_to_vector_0, '0', blocks_delay_0_3, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', guppi_guppi_sink_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_vector_to_stream_2, '0', blocks_complex_to_interleaved_char_0, '0']
- [blocks_vector_to_stream_2, '0', blocks_multiply_const_vxx_1, '0']
- [fft_vxx_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_3, '0', blocks_vector_to_stream_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
