options:
  parameters:
    generate_options: qt_gui
    id: ofdm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/daniel/grcon2022-ctf/ofdm101.sigmf-data
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/grcon2022-ctf/ofdm.c64
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '2358'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: 1.0 - 1.72873e-6
    freq_offset: 3728.1287/samp_rate
    noise_voltage: '2.5e-3'
    seed: '17827'
    taps: '[1.0, 0.1 * np.exp(1j*2.8712), 0.05*np.exp(1j*0.2871), 0.07*np.exp(1j*3.8723), 0.15*np.exp(1j*1.8732), 0, 0, 0, 0.1 * np.exp(1j * 1.8723), 0, 0, 0, 0, 0, 0.2 * np.exp(1j*0.1872)]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', channels_channel_model_0, '0']
- [blocks_skiphead_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', blocks_skiphead_0, '0']
- [channels_channel_model_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
