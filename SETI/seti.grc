options:
  parameters:
    generate_options: qt_gui
    id: seti
    output_language: python
    title: SETI
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '6000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: polarization.f32
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: polarization_avg.f32
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: power.f32
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/ctf/seti/ATA_59848_08825_HIP91262_polX.sigmf-data
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/daniel/ctf/seti/ATA_59848_08825_HIP91262_polY.sigmf-data
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: 2**7
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: 2**7
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Obtaining V = -Im(Ex * conjugate(Ey))
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1j
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate * 100
    type: complex
  states: {state: bypassed}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.low_pass(1, samp_rate, 5, 1)
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.low_pass(1, samp_rate, 100, 10)
    type: fff
  states: {}
- name: fir_filter_xxx_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.low_pass(1, samp_rate, 300, 25)
    type: ccc
  states: {}
- name: fir_filter_xxx_2_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.low_pass(1, samp_rate, 300, 25)
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    comment: Obtaining R=X+i*Y, L=X-i*Y, and |R|^2- |L|^2
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: samp_rate * 100
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: samp_rate * 100
    srate: samp_rate
    type: float
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    file: doppler.txt
    samp_rate: samp_rate
    t0: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [blocks_complex_to_imag_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_imag_0, '0', fir_filter_xxx_1, '0']
- [blocks_complex_to_imag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_sub_xx_2, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_sub_xx_2, '1']
- [blocks_complex_to_mag_squared_1, '0', blocks_sub_xx_1, '0']
- [blocks_complex_to_mag_squared_1_0, '0', blocks_sub_xx_1, '1']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_1, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_add_xx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_sub_xx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', satellites_doppler_correction_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_2_0, '0']
- [blocks_sub_xx_0, '0', blocks_complex_to_mag_squared_1_0, '0']
- [blocks_sub_xx_1, '0', fir_filter_xxx_1, '0']
- [blocks_sub_xx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_2, '0', fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', blocks_file_sink_0_0_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [fir_filter_xxx_1, '0', blocks_file_sink_0_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [fir_filter_xxx_2, '0', blocks_complex_to_mag_squared_0, '0']
- [fir_filter_xxx_2_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [satellites_doppler_correction_0, '0', blocks_multiply_xx_0, '0']
- [satellites_doppler_correction_0, '0', fir_filter_xxx_2, '0']
- [satellites_doppler_correction_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
